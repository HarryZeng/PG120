# Keil uVision project PG120.uvprojx, settings and files
target STM32_USART (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_PG120 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Peripherals\inc;..\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib_CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Lib_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c misc.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_pwr.c
  group Peripherals
    ../Peripherals/src/: usart.c delay.c stm32f10x_it.c display.c key.c menu.c flash.c SelfStudy.c
  group user
    ./: main.c BSP_Init.c
    ../Peripherals/src/: PG120.c
    ../: readme.txt
